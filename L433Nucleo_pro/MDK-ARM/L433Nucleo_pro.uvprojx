# Keil uVision project L433Nucleo_pro.uvprojx, settings and files
target L433Nucleo_pro (ARM-ADS)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: L433Nucleo_pro
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L433xx
  c include: ../Inc;  ../Drivers/STM32L4xx_HAL_Driver/Inc;  ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Drivers/CMSIS/Include;../Middlewares/tc_iot;../Middlewares/tc_iot/include;../Middlewares/tc_iot/include/common;../Middlewares/tc_iot/include/platform;../Middlewares/tc_iot/platform/stm32L4xx;../Middlewares/tc_iot/user_logic;../Middlewares/tc_iot/user_logic/example_smartbox
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l433xx.s
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c main.c freertos.c stm32l4xx_hal_timebase_TIM.c stm32l4xx_it.c retarget.c board.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_tim.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c timers.c queue.c croutine.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group net_by_at
    ../Src/net_by_at/: at_driver.c at_for_sim900.c
  group tcIotSuit/platform
    ../Middlewares/tc_iot/src/platform/stm32l4xx/: tc_iot_hal_net.c tc_iot_hal_os.c tc_iot_hal_timer.c
  group tcIotSuit/common
    ../Middlewares/tc_iot/src/common/: tc_iot_base64.c tc_iot_certs.c tc_iot_hmac.c tc_iot_http_utils.c tc_iot_json.c tc_iot_log.c tc_iot_md5.c tc_iot_url.c tc_iot_ya_buffer.c
  group tcIotSuit/iotsuite
    ../Middlewares/tc_iot/src/iotsuite/: tc_iot_client.c tc_iot_mqtt.c tc_iot_shadow.c tc_iot_shadow_property.c tc_iot_token.c
  group tcIotsuite/extern/jsmn
    ../Middlewares/tc_iot/external/jsmn/: jsmn.c
  group tcIotsuite/extern/paho_mqtt
    ../Middlewares/tc_iot/external/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group tcIotSuit/user_logic
    ../Middlewares/tc_iot/user_logic/example_smartbox/: app_main.c
software components: CMSIS:CORE 4.3.0
